<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Seven Segment Display Module\Seven Segment Display Module.ewp</path>
  </project>
  <batchBuild/>
</workspace>


